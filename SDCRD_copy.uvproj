# Keil uVision project SDCRD_copy.uvproj, settings and files
target mbed FRDM-KL25Z (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: SDCRD_copy
  AfterMake: fromelf --bin -o build\SDCRD_copy_KL25Z.bin build\SDCRD_copy.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  MBED_BUILD_TIMESTAMP=1458862868.31,  TARGET_KLXX,  TARGET_KL25Z,  TARGET_CORTEX_M,  TARGET_LIKE_MBED,  TARGET_M0P,  TARGET_Freescale,  TOOLCHAIN_ARM_STD,  __MBED__=1,  __CORTEX_M0PLUS,  TOOLCHAIN_ARM,  TARGET_LIKE_CORTEX_M0,  ARM_MATH_CM0PLUS,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  SDFileSystem;  SDFileSystem/FATFileSystem;  SDFileSystem/FATFileSystem/ChaN;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TARGET_Freescale;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    SDFileSystem/: SDFileSystem.cpp main.cpp
    SDFileSystem/FATFileSystem/: FATFileSystem.cpp FATFileHandle.cpp FATDirHandle.cpp
    SDFileSystem/FATFileSystem/ChaN/: diskio.cpp ccsbcs.cpp ff.cpp
